options:
  parameters:
    author: Abel Nunez
    generate_options: qt_gui
    id: test_techniquepdu
    output_language: python
    title: Technique PDU Generator Test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("trigger")
    period: '1000'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: pdu_pdu_to_stream_x_0
  id: pdu_pdu_to_stream_x
  parameters:
    early_behavior: pdu.EARLY_BURST_APPEND
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      import threading
      import time
      def timeout():
          time.sleep(30)
          self.stop()
          self.wait()
          print("Test timed out after 30 seconds.")
      threading.Thread(target=timeout, daemon=True).start()
    section: main_after_start
  states: {}
- name: techniquemaker_techniquepdu_0
  id: techniquemaker_pdu_generator
  parameters:
    bandwidth_hz: '200000'
    chunks: '5'
    cp_length: '256'
    enable_command_port: 'False'
    end_freq_hz: '100000'
    fft_size: '1024'
    filter_type: '''none'''
    frequencies_str: '''1000 2000 3000'''
    hop_duration_seconds: '0.01'
    hop_frequencies_str: '''-100000 0 100000'''
    interference_type: '''sinc'''
    modulated_frequency: '1000'
    normalization_type: '''rms'''
    num_subcarriers: '600'
    output_mode: '''Continuous (Stream)'''
    rolloff: '0.35'
    sample_rate_hz: samp_rate
    song_name: '''Baby Shark'''
    start_freq_hz: '-100000'
    sweep_hz: '500000'
    sweep_range_hz: '1000000'
    sweep_rate_hz_s: '100000'
    sweep_type: '''triangle'''
    symbol_rate_hz: '50000'
    target_value: '1.0'
    technique: '''Swept Noise'''
    technique_length_seconds: '1.0'
    technique_width_hz: '1000000'
    tones: '5'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, techniquemaker_techniquepdu_0, trigger]
- [blocks_throttle2_0, '0', qtgui_waterfall_sink_x_0, '0']
- [pdu_pdu_to_stream_x_0, '0', blocks_throttle2_0, '0']
- [techniquemaker_techniquepdu_0, '0', blocks_throttle2_0, '0']
- [techniquemaker_techniquepdu_0, pdu, blocks_message_debug_0, print]
- [techniquemaker_techniquepdu_0, pdu, pdu_pdu_to_stream_x_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
